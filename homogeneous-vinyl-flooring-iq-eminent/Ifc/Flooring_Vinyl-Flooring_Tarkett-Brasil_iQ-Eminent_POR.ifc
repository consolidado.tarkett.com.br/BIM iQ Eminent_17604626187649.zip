Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 2fc6fd0f-b5f1-42a0-88c2-cd1c7de94e03, NumberOfSaves: 50], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Interne]
File name: Flooring_Vinyl-Flooring_Tarkett-Brasil_iQ-Eminent_POR.ifc
Time: 2025-09-04T08:57:43+01:00
Organization: BIMobject
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENG) - IFC 23.4.1.0

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propriétaire; Project Address: ## RueVille, Code postal; Project Issue Date: 05/09/2025; Project Name: Nom du projet; Project Number: Numéro du projet; Project Status: Etat du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propriétaire; Project Address: ## RueVille, Code postal; Project Issue Date: 05/09/2025; Project Name: Nom du projet; Project Number: Numéro du projet; Project Status: Etat du projet

# IfcBuildingStorey: Level:Pointe 8 mm (2)
Pset_AirSideSystemInformation - sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Pointe 8 mm; Type: Pointe 8 mm; Type Id: 27
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Marqueur de niveau - Cercle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Pointe 8 mm
Name | LongName = Pset_AirSideSystemInformation, Name = Identity Data, Name | Elevation (mm) = Constraints, Elevation (mm)
Level 1 | Level 1 | 0
Niveau 2 | Niveau 2 | 4000

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Blue, Floor:Tarkett Brasil - iQ Eminent - Blue:395481
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Blue 0889 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Default Thickness: 2 mm; Function: Interior
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Blue; Type Name: Tarkett Brasil - iQ Eminent - Blue; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/; Version: 1
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - Reference: Floor:Tarkett Brasil - iQ Eminent - Blue; TotalThickness: 2 mm
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Blue
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Blue; Type: Tarkett Brasil - iQ Eminent - Blue; Type Id: 393501
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Clay, Floor:Tarkett Brasil - iQ Eminent - Clay:395525
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Clay 0887 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Clay; Type Name: Tarkett Brasil - iQ Eminent - Clay; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Clay
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Clay
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Clay; Type: Tarkett Brasil - iQ Eminent - Clay; Type Id: 393505
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Beige, Floor:Tarkett Brasil - iQ Eminent - Dusty Beige:395549
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Beige 0998 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Beige; Type Name: Tarkett Brasil - iQ Eminent - Dusty Beige; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Beige
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Beige
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Beige; Type: Tarkett Brasil - iQ Eminent - Dusty Beige; Type Id: 393511
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Blue, Floor:Tarkett Brasil - iQ Eminent - Dusty Blue:395565
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Blue 0907 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Blue; Type Name: Tarkett Brasil - iQ Eminent - Dusty Blue; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Blue
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Blue
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Blue; Type: Tarkett Brasil - iQ Eminent - Dusty Blue; Type Id: 393513
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Brick, Floor:Tarkett Brasil - iQ Eminent - Dusty Brick:395581
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Brick 0999 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Brick; Type Name: Tarkett Brasil - iQ Eminent - Dusty Brick; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Brick
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Brick
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Brick; Type: Tarkett Brasil - iQ Eminent - Dusty Brick; Type Id: 393515
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Green, Floor:Tarkett Brasil - iQ Eminent - Dusty Green:395595
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Green 0925 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Green; Type Name: Tarkett Brasil - iQ Eminent - Dusty Green; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Green
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Green
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Green; Type: Tarkett Brasil - iQ Eminent - Dusty Green; Type Id: 393517
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Grey, Floor:Tarkett Brasil - iQ Eminent - Dusty Grey:395620
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Grey 0908 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Grey; Type Name: Tarkett Brasil - iQ Eminent - Dusty Grey; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Grey
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Grey
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Grey; Type: Tarkett Brasil - iQ Eminent - Dusty Grey; Type Id: 393519
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Dusty Sand, Floor:Tarkett Brasil - iQ Eminent - Dusty Sand:395629
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Dusty Sand 0928 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Dusty Sand; Type Name: Tarkett Brasil - iQ Eminent - Dusty Sand; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Sand
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Dusty Sand
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Dusty Sand; Type: Tarkett Brasil - iQ Eminent - Dusty Sand; Type Id: 393521
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Light Beige, Floor:Tarkett Brasil - iQ Eminent - Light Beige:395638
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Light Beige 0885 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Light Beige; Type Name: Tarkett Brasil - iQ Eminent - Light Beige; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Light Beige
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Light Beige
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Light Beige; Type: Tarkett Brasil - iQ Eminent - Light Beige; Type Id: 393529
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Light Grey, Floor:Tarkett Brasil - iQ Eminent - Light Grey:395647
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Light Grey 0811 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Light Grey; Type Name: Tarkett Brasil - iQ Eminent - Light Grey; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Light Grey
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Light Grey
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Light Grey; Type: Tarkett Brasil - iQ Eminent - Light Grey; Type Id: 393531
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - Sand, Floor:Tarkett Brasil - iQ Eminent - Sand:395656
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - Sand 0883 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT Sand; Type Name: Tarkett Brasil - iQ Eminent - Sand; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - Sand
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - Sand
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - Sand; Type: Tarkett Brasil - iQ Eminent - Sand; Type Id: 393543
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no

# IfcCovering: Floor:Tarkett Brasil - iQ Eminent - White, Floor:Tarkett Brasil - iQ Eminent - White:395665
In: Level 1
Type - PredefinedType: FLOORING; Material: Tarkett Brasil - iQ Eminent - White 0904 2 mm
Type - Other - Category: Floors; Family Name: Floor
Type - Construction - Function: Interior; Default Thickness: 2 mm
Type - Data - Aquecimento de piso: Yes; Carga estática: ≤ 2kV; Classificação de resistência ao fogo: Bfl - s1; Dimensões: Rolo: 2m x 23m; Emissão de COV: ≤ 10 μg/m³; Espessura: 2mm; Espessura da camada de desgaste: 2; Identação residual: ≤ 0.10 mm; Peso total: 2.75 kg/m²; Proteção superficial: New iQ PUR; Resistência ao escorregamento: μ ≥ 0.30 | R9; Resistência química: Excelente; Resistência térmica: 0.0100 (m²·K)/W; Solidez à luz: ≥ 7; Teor de Aglutinantes: Tipo I
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - Version: 1; Assembly Code: C3020400; Assembly Description: Flooring; Cost: 0; Date Created: 2025/09/05; Date Updated: 2025/09/05; Description: Piso vinílico homogêneo; Installation instructions: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Manufacturer: Tarkett Brasil; Model: iQ Eminent; Product certification: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Product data url: https://www.bimobject.com/tarkett-brasil/product/homogeneous-vinyl-flooring-iq-eminent; Product SKU: homogeneous-vinyl-flooring-iq-eminent; Product url: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Technical description: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; Type Comments: EMINENT White; Type Name: Tarkett Brasil - iQ Eminent - White; URL: https://tarkett.com.br/categoria/piso-vinilico-mantas-comerciais/linha-iq-eminent; URL EMEA: https://professionals.tarkett.com/en_EU/
Type - Analytical Properties - Absorptance: 0.1; Heat Transfer Coefficient (U): 100 kg/K/s3; Roughness: 1; Thermal Mass: 0 kg/K/s2; Thermal Resistance (R): 0.01 s3*K/kg
Type - Pset_ConcreteElementGeneral - FireRating: Bfl - s1
Type - Pset_CoveringCommon - FireRating: Bfl - s1; AcousticRating: -; FragilityRating: 34 | 43
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tarkett Brasil
Classification: C3020400 Flooring (Uniformat)
Pset_CoveringCommon - TotalThickness: 2 mm; Reference: Floor:Tarkett Brasil - iQ Eminent - White
Pset_QuantityTakeOff - Reference: Floor:Tarkett Brasil - iQ Eminent - White
Other - Family: Floor; Family and Type: Floor: Tarkett Brasil - iQ Eminent - White; Type: Tarkett Brasil - iQ Eminent - White; Type Id: 393547
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 4 m2; Elevation at Top: 0 mm; Elevation at Top Core: 0 mm; Elevation at Bottom: -2 mm; Elevation at Bottom Core: -2 mm; Perimeter: 8000 mm; Thickness: 2 mm; Volume: 0.008 m3
Identity Data - Has Association: no
Phasing - Phase Created: Nouvelle construction
Structural - Structural: no
